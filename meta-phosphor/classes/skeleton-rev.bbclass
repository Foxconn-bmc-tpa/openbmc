DEPENDS += "i2c-tools"
SRCREV ?= "af24fcbf872822f7a7e163e894f58a1543b2515f"
SKELETON_URI ?= "git://github.com/foxconn-bmc-tpa/skeleton;branch=foxconn-g2_new"
