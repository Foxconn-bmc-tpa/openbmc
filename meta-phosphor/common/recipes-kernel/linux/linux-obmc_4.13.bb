KBRANCH ?= "foxconn-g2-4.13 "
LINUX_VERSION ?= "4.13.16"

SRCREV="1aab48b952cb74ea4932340e6d275d7f5712c308"

require linux-obmc.inc
